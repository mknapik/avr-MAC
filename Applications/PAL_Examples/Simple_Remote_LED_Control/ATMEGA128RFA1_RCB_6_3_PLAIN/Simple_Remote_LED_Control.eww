<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Simple_Remote_LED_Control.ewp</path>
  </project>
</workspace>


