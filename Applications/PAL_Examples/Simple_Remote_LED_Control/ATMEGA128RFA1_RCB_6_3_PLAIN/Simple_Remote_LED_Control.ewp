# IAR project Simple_Remote_LED_Control.ewp, settings and files
configuration Release (AVR)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x200
  General.SCRStackSize: 32
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-3s-ec_mul-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x40
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: DEBUG=0; TAL_TYPE=ATMEGARF_TAL_1; PAL_TYPE=ATMEGA128RFA1; PAL_GENERIC_TYPE=MEGA_RF; BOARD_TYPE=RCB_6_3_PLAIN; HIGHEST_STACK_LAYER=PAL
  ICCAVR.CCDiagSuppress: Pa091
  ICCAVR.newCCIncludePaths: ..\Inc; ..\..\..\..\Include; ..\..\..\..\TAL\Inc; ..\..\..\..\TAL\ATMEGARF_TAL_1\Inc; ..\..\..\..\PAL\Inc; ..\..\..\..\PAL\MEGA_RF\Generic\Inc; ..\..\..\..\PAL\MEGA_RF\ATMEGA128RFA1\Inc; ..\..\..\..\PAL\MEGA_RF\ATMEGA128RFA1\Boards; ..\..\..\..\PAL\MEGA_RF\ATMEGA128RFA1\Boards\RCB_6_3_PLAIN
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm128rfa1.xcl
configuration Debug (AVR, debug)
  as the first configuration, except:
  group (top)
    ../Src/: main.c
  group PAL
    ../../../../PAL/MEGA_RF/Generic/Src/: pal.c pal_utils.c
    ../../../../PAL/MEGA_RF/ATMEGA128RFA1/Src/: pal_mcu_generic.c pal_timer.c
  group PAL/Board
    ../../../../PAL/MEGA_RF/ATMEGA128RFA1/Boards/RCB_6_3_PLAIN/: pal_board.c
    ../../../../PAL/MEGA_RF/ATMEGA128RFA1/Src/: pal_irq.c
