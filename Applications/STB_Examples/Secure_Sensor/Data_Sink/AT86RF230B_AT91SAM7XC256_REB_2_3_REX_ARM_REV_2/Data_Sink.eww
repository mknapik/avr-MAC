<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$\Data_Sink.ewp</path>
  </project>
</workspace>
