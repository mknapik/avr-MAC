# IAR project Sensor.ewp, settings and files
configuration Sensor (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: AT91SAM7X256 Atmel AT91SAM7X256
  ICCARM.CCDefines: NOTRACE; SIO_HUB; UART0; DEBUG=0; FFD; REDUCED_PARAM_CHECK; ENABLE_TRX_SRAM; TAL_TYPE=AT86RF231; PAL_TYPE=AT91SAM7X256; PAL_GENERIC_TYPE=ARM7; BOARD_TYPE=REB_4_0_2_REX_ARM_REV_3; HIGHEST_STACK_LAYER=MAC; SAL_TYPE=AT86RF2xx; STB_ON_SAL
  ICCARM.CCIncludePath2: ..\Inc; ..\..\Inc; ..\..\..\..\Helper_Files\SIO_Support\Inc; ..\..\..\..\..\Include; ..\..\..\..\..\PAL\Inc; ..\..\..\..\..\PAL\ARM7\Generic\Inc; ..\..\..\..\..\PAL\ARM7\AT91SAM7X256\Inc; ..\..\..\..\..\PAL\ARM7\AT91SAM7X256\Boards; ..\..\..\..\..\PAL\ARM7\AT91SAM7X256\Boards\REB_4_0_2_REX_ARM_REV_3; ..\..\..\..\..\TAL\Inc; ..\..\..\..\..\TAL\AT86RF231\Inc; ..\..\..\..\..\MAC\Inc; ..\..\..\..\..\Resources\Queue_Management\Inc; ..\..\..\..\..\Resources\Buffer_Management\Inc; ..\..\..\..\..\SAL\AT86RF2xx\Inc; ..\..\..\..\..\SAL\Inc; ..\..\..\..\..\STB\Inc
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.AUserIncludes: ..\..\..\..\..\PAL\ARM7\AT91SAM7X256\Inc
  OBJCOPY.OOCOutputFile: Sensor.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: flash.icf
  ILINK.IlinkProgramEntryLabel: resetHandler
  group (top)
    ../Src/: main.c
    ../../../../Helper_Files/SIO_Support/Src/: sio_handler.c
    ../../Src/: stb_app_defs.c
    ../../../../Helper_Files/SIO_Support/IAR_Support/: write.c
  group MAC
    ../../../../../MAC/Src/: mac.c mac_associate.c mac_beacon.c mac_callback_wrapper.c mac_data_ind.c mac_data_req.c mac_disassociate.c mac_dispatcher.c mac_mcps_data.c mac_misc.c mac_orphan.c mac_pib.c mac_poll.c mac_process_beacon_frame.c mac_process_tal_tx_frame_status.c mac_rx_enable.c mac_scan.c mac_start.c mac_sync.c mac_tx_coord_realignment_command.c
  group MAC_API
    ../../../../../MAC/Src/: mac_api.c usr_mcps_data_ind.c usr_mcps_purge_conf.c usr_mlme_associate_ind.c usr_mlme_beacon_notify_ind.c usr_mlme_comm_status_ind.c usr_mlme_disassociate_conf.c usr_mlme_disassociate_ind.c usr_mlme_get_conf.c usr_mlme_orphan_ind.c usr_mlme_poll_conf.c usr_mlme_rx_enable_conf.c usr_mlme_set_conf.c usr_mlme_start_conf.c usr_mlme_sync_loss_ind.c
  group PAL
    ../../../../../PAL/ARM7/Generic/Src/: pal.c pal_timer.c pal_trx_access.c pal_uart.c pal_utils.c
    ../../../../../PAL/ARM7/AT91SAM7X256/Src/: pal_sio_hub.c
  group PAL/Board
    ../../../../../PAL/ARM7/AT91SAM7X256/Boards/REB_4_0_2_REX_ARM_REV_3/: pal_board.c pal_irq.c
  group PAL/startup
    ../../../../../PAL/ARM7/AT91SAM7X256/Startup/: board_cstartup_iar.s
  group Resources
    ../../../../../Resources/Buffer_Management/Src/: bmm.c
    ../../../../../Resources/Queue_Management/Src/: qmm.c
  group SAL
    ../../../../../SAL/AT86RF2xx/Src/: sal.c
  group STB
    ../../../../../STB/Src/: stb.c stb_help.c
  group TAL
    ../../../../../TAL/AT86RF231/Src/: tal.c tal_ed.c tal_init.c tal_irq_handler.c tal_pib.c tal_pwr_mgmt.c tal_rx.c tal_rx_enable.c tal_slotted_csma.c tal_tx.c
