<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$\Star_High_Rate.ewp</path>
  </project>
</workspace>