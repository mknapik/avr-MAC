<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$\Device_BC_Data.ewp</path>
  </project>
</workspace>