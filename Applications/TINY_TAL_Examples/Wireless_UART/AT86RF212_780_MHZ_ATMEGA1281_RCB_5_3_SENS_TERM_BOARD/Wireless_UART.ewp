# IAR project Wireless_UART.ewp, settings and files
configuration Release (AVR)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x200
  General.SCRStackSize: 32
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-3s-ec_mul-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x40
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: DEBUG=0; CHINESE_BAND; SIO_HUB; USB0; TAL_TYPE=AT86RF212; PAL_TYPE=ATMEGA1281; PAL_GENERIC_TYPE=AVR; BOARD_TYPE=RCB_5_3_SENS_TERM_BOARD; HIGHEST_STACK_LAYER=TINY_TAL
  ICCAVR.newCCIncludePaths: ..\Inc; ..\..\..\..\Include; ..\..\..\..\TINY_TAL\Inc; ..\..\..\..\TINY_TAL\AT86RF212\Inc; ..\..\..\..\TAL\AT86RF212\Inc; ..\..\..\..\PAL\Inc; ..\..\..\..\PAL\AVR\Generic\Inc; ..\..\..\..\PAL\AVR\ATMEGA1281\Inc; ..\..\..\..\PAL\AVR\ATMEGA1281\Boards; ..\..\..\..\PAL\AVR\ATMEGA1281\Boards\RCB_5_3_SENS_TERM_BOARD
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm1281.xcl
configuration Debug (AVR, debug)
  as the first configuration, except:
  group (top)
    ../Src/: main.c
  group PAL
    ../../../../PAL/AVR/Generic/Src/: pal.c pal_timer.c pal_trx_access.c pal_uart.c pal_usb_ftdi.c pal_utils.c
    ../../../../PAL/AVR/ATMEGA1281/Src/: pal_sio_hub.c
  group PAL/Board
    ../../../../PAL/AVR/ATMEGA1281/Boards/RCB_5_3_SENS_TERM_BOARD/: pal_board.c pal_irq.c
  group TINY_TAL
    ../../../../TINY_TAL/AT86RF212/Src/: tiny_tal.c tiny_tal_init.c tiny_tal_irq_handler.c tiny_tal_pib.c tiny_tal_pwr_mgmt.c tiny_tal_rx.c tiny_tal_rx_enable.c tiny_tal_tx.c
