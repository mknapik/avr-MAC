# IAR project Wireless_UART.ewp, settings and files
configuration Release (AVR)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x200
  General.SCRStackSize: 32
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-3s-ec_mul-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x40
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: DEBUG=0; SIO_HUB; USB0; TAL_TYPE=AT86RF230B; PAL_TYPE=AT90USB1287; PAL_GENERIC_TYPE=AVR; BOARD_TYPE=USBSTICK_C; HIGHEST_STACK_LAYER=TINY_TAL
  ICCAVR.newCCIncludePaths: ..\Inc; ..\..\..\..\Include; ..\..\..\..\TINY_TAL\Inc; ..\..\..\..\TINY_TAL\AT86RF230B\Inc; ..\..\..\..\TAL\AT86RF230B\Inc; ..\..\..\..\PAL\Inc; ..\..\..\..\PAL\AVR\Generic\Inc; ..\..\..\..\PAL\AVR\AT90USB1287\Inc; ..\..\..\..\PAL\AVR\AT90USB1287\Boards; ..\..\..\..\PAL\AVR\AT90USB1287\Boards\USBSTICK_C
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgusb1287.xcl
configuration Debug (AVR, debug)
  as the first configuration, except:
  group (top)
    ../Src/: main.c
  group PAL
    ../../../../PAL/AVR/Generic/Src/: pal.c pal_timer.c pal_trx_access.c pal_uart.c pal_utils.c
    ../../../../PAL/AVR/AT90USB1287/Src/: pal_sio_hub.c pal_usb.c
  group PAL/Board
    ../../../../PAL/AVR/AT90USB1287/Boards/USBSTICK_C/: pal_board.c pal_irq.c
  group TINY_TAL
    ../../../../TINY_TAL/AT86RF230B/Src/: tiny_tal.c tiny_tal_init.c tiny_tal_irq_handler.c tiny_tal_pib.c tiny_tal_pwr_mgmt.c tiny_tal_rx.c tiny_tal_rx_enable.c tiny_tal_tx.c
