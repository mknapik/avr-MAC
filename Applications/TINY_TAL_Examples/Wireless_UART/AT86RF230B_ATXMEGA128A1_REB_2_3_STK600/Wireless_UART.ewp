# IAR project Wireless_UART.ewp, settings and files
configuration Release (AVR)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x200
  General.SCRStackSize: 32
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-6s-xmega-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x40
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: DEBUG=0; SIO_HUB; UART1; TAL_TYPE=AT86RF230B; PAL_TYPE=ATXMEGA128A1; PAL_GENERIC_TYPE=XMEGA; BOARD_TYPE=REB_2_3_STK600; HIGHEST_STACK_LAYER=TINY_TAL
  ICCAVR.newCCIncludePaths: ..\Inc; ..\..\..\..\Include; ..\..\..\..\TINY_TAL\Inc; ..\..\..\..\TINY_TAL\AT86RF230B\Inc; ..\..\..\..\TAL\AT86RF230B\Inc; ..\..\..\..\PAL\Inc; ..\..\..\..\PAL\XMEGA\Generic\Inc; ..\..\..\..\PAL\XMEGA\ATXMEGA128A1\Inc; ..\..\..\..\PAL\XMEGA\ATXMEGA128A1\Boards; ..\..\..\..\PAL\XMEGA\ATXMEGA128A1\Boards\REB_2_3_STK600
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgxm128a1.xcl
configuration Debug (AVR, debug)
  as the first configuration, except:
  group (top)
    ../Src/: main.c
  group PAL
    ../../../../PAL/XMEGA/Generic/Src/: pal.c pal_timer.c pal_trx_access.c pal_uart.c pal_utils.c
    ../../../../PAL/XMEGA/ATXMEGA128A1/Src/: pal_sio_hub.c
  group PAL/Board
    ../../../../PAL/XMEGA/ATXMEGA128A1/Boards/REB_2_3_STK600/: pal_board.c pal_irq.c
  group TINY_TAL
    ../../../../TINY_TAL/AT86RF230B/Src/: tiny_tal.c tiny_tal_init.c tiny_tal_irq_handler.c tiny_tal_pib.c tiny_tal_pwr_mgmt.c tiny_tal_rx.c tiny_tal_rx_enable.c tiny_tal_tx.c
