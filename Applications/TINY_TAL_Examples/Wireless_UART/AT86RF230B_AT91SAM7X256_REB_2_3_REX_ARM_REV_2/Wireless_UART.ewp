# IAR project Wireless_UART.ewp, settings and files
configuration Wireless_UART (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: at91sam7x256 Atmel at91sam7x256
  ICCARM.CCDefines: NOTRACE; DEBUG=0; SIO_HUB; UART0; TAL_TYPE=AT86RF230B; PAL_TYPE=AT91SAM7X256; PAL_GENERIC_TYPE=ARM7; BOARD_TYPE=REB_2_3_REX_ARM_REV_2; HIGHEST_STACK_LAYER=TINY_TAL
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\Include; ..\..\..\..\TINY_TAL\Inc; ..\..\..\..\TINY_TAL\AT86RF230B\Inc; ..\..\..\..\TAL\AT86RF230B\Inc; ..\..\..\..\PAL\Inc; ..\..\..\..\PAL\ARM7\Generic\Inc; ..\..\..\..\PAL\ARM7\AT91SAM7X256\Inc; ..\..\..\..\PAL\ARM7\AT91SAM7X256\Boards; ..\..\..\..\PAL\ARM7\AT91SAM7X256\Boards\REB_2_3_REX_ARM_REV_2
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.AUserIncludes: ..\..\..\..\..\..\PAL\ARM7\AT91SAM7X256\Inc
  OBJCOPY.OOCOutputFile: Wireless_UART.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: flash.icf
  ILINK.IlinkProgramEntryLabel: resetHandler
  group (top)
    ../Src/: main.c
  group PAL
    ../../../../PAL/ARM7/Generic/Src/: pal.c pal_timer.c pal_trx_access.c pal_uart.c pal_utils.c
    ../../../../PAL/ARM7/AT91SAM7X256/Src/: pal_sio_hub.c
  group PAL/Board
    ../../../../PAL/ARM7/AT91SAM7X256/Boards/REB_2_3_REX_ARM_REV_2/: pal_board.c pal_irq.c
  group PAL/startup
    ../../../../PAL/ARM7/AT91SAM7X256/Startup/: board_cstartup_iar.s
  group TINY_TAL
    ../../../../TINY_TAL/AT86RF230B/Src/: tiny_tal.c tiny_tal_init.c tiny_tal_irq_handler.c tiny_tal_pib.c tiny_tal_pwr_mgmt.c tiny_tal_rx.c tiny_tal_rx_enable.c tiny_tal_tx.c
